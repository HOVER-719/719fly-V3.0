# Keil uVision project flight_control.uvprojx, settings and files
target flight_control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flight_control +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\app\main;.\embedded\rtos_sdk\portable\RVDS\ARM_CM3;.\embedded\rtos_sdk\include;.\embedded\include;.\app\ctrl;.\app\communicate;.\app\sensors;.\embedded\include;.\embedded\CMSIS\include;.\app\math;.\app\modes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group embedded/rtos_sdk/src
    ./embedded/rtos_sdk/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group embedded/rtos_sdk/portable
    ./embedded/rtos_sdk/portable/RVDS/ARM_CM3/: port.c
    ./embedded/rtos_sdk/portable/MemMang/: heap_4.c
  group app/main
    ./app/main/: main.c stm32f10x_it.c
  group app/ctrl
    ./app/ctrl/: altitude_control.c altitude_measure.c control.c paramsave.c pid.c position_control.c position_measure.c structconfig.h
  group embedded
    ./embedded/: delay.c exit.c flash.c iic.c led.c motor.c mpu6050.c nvic.c oled.c openmv.c power.c RC.c si24r1.c spi.c SPL06_001.c sys.c system.c tfmini.c tim.c usart.c
  group app/sensors
    ./app/sensors/: imu.c
  group embedded/CMSIS
    ./embedded/CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group app/math
    ./app/math/: filter.c Kalman.c
  group app/modes
    ./app/modes/: M1_ Stablize.c M2_AttCtrl.c M3_PosCtrl.c M4_Auto.c M5_Safe.c
software components: CMSIS:CORE 5.6.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
